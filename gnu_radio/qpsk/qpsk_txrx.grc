options:
  parameters:
    author: oshears
    generate_options: qt_gui
    id: ofdm_txrx
    output_language: python
    title: OFDM TX RX
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 1535e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '544000'
  states: {}
- name: variable_constellation_0
  id: variable_constellation
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    type: calcdist
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '4'
    min: '0'
    num_samps: '16'
    repeat: 'False'
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/oshears/Documents/gnu_radio/qpsk/tx_data
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/oshears/Documents/gnu_radio/qpsk/tx_data_complex
    type: complex
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: /home/oshears/Documents/gnu_radio/qpsk/rx_data_complex
    type: complex
  states: {}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: /home/oshears/Documents/gnu_radio/qpsk/rx_data
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/oshears/Documents/gnu_radio/qpsk/tx_data
    repeat: 'True'
    type: byte
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: variable_constellation_0
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: variable_constellation_0
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: '2'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: soapy_bladerf_sink_0
  id: soapy_bladerf_sink
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_file_sink_0, '0']
- [analog_random_source_x_0, '0', digital_constellation_modulator_0, '0']
- [blocks_file_source_0, '0', digital_constellation_modulator_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_file_sink_0_1, '0']
- [digital_constellation_modulator_0, '0', blocks_file_sink_0_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_const_sink_x_0, '0']
- [digital_constellation_modulator_0, '0', soapy_bladerf_sink_0, '0']
- [soapy_bladerf_source_0, '0', blocks_file_sink_0_0_0, '0']
- [soapy_bladerf_source_0, '0', digital_constellation_decoder_cb_0, '0']
- [soapy_bladerf_source_0, '0', qtgui_const_sink_x_1, '0']

metadata:
  file_format: 1
