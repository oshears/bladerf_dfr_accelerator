options:
  parameters:
    generate_options: qt_gui
    id: lpbk_verif
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/oshears/Documents/bladeRF/bladerf_dfr_accelerator/gnu_radio/loopback/tx_lpbk.bin
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/oshears/Documents/bladeRF/bladerf_dfr_accelerator/gnu_radio/loopback/tx_lpbk.bin
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    color3: blue
    color4: red
    marker3: '0'
    marker4: '0'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    style3: '0'
    style4: '0'
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_file_source_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [blocks_file_source_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_throttle_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
