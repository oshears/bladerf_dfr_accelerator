options:
  parameters:
    author: Nuand, LLC <bladeRF@nuand.com>
    category: Custom
    description: A simple flowgraph that demonstrates the usage of loopback modes.
    generate_options: qt_gui
    id: bladeRF_loopback
    output_language: python
    title: '"bladeRF loopback example"'
  states: {}

blocks:
- name: bladerf_rx_args
  id: variable
  parameters:
    value: '"bladerf=0,loopback=none,buffers=16,buflen=4096,num_xfers=8,verbosity=info,rxmux=digital"'
  states: {}
- name: bladerf_selection
  id: variable
  parameters:
    value: str(instance) if serial == "" else serial
  states: {}
- name: bladerf_tx_args
  id: variable
  parameters:
    value: '"bladerf=0,buffers=16,buflen=4096,num_xfers=8,verbosity=verbose"'
  states: {}
- name: gui_bladerf_rx_args
  id: variable_qtgui_label
  parameters:
    gui_hint: 'tabs@0 : 11, 0, 1, 10'
    label: '"bladeRF RX arguments"'
    type: string
    value: bladerf_rx_args
  states: {}
- name: gui_bladerf_tx_args
  id: variable_qtgui_label
  parameters:
    gui_hint: 'tabs@1: 11, 0, 1, 10'
    label: '"bladeRF TX arguments"'
    type: string
    value: bladerf_tx_args
  states: {}
- name: gui_rx_bandwidth
  id: variable_qtgui_range
  parameters:
    gui_hint: 'tabs@0 : 1, 2, 1, 2'
    label: Bandwidth
    start: 1.5e6
    step: 0.5e6
    stop: 28e6
    value: rx_bandwidth
  states: {}
- name: gui_rx_frequency
  id: variable_qtgui_range
  parameters:
    gui_hint: 'tabs@0 : 0, 0, 1, 5'
    label: Frequency
    start: '0'
    step: 1e6
    stop: 3.8e9
    value: rx_frequency
  states: {}
- name: gui_rx_lna_gain
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 'tabs@0 : 0, 9, 1, 1'
    label: LNA Gain
    label0: 0 dB
    label1: 3 dB
    label2: 6 dB
    num_opts: '3'
    option0: '0'
    option1: '3'
    option2: '6'
    type: int
    value: rx_lna_gain
  states: {}
- name: gui_rx_sample_rate
  id: variable_qtgui_range
  parameters:
    gui_hint: 'tabs@0 : 1, 0, 1, 2'
    label: Sample Rate
    start: 1.5e6
    step: 500e3
    stop: 40e6
    value: rx_sample_rate
  states: {}
- name: gui_rx_vga_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'tabs@0 : 0, 5, 1, 4'
    label: RX VGA1 + VGA2 Gain
    start: '5'
    step: '1'
    stop: '60'
    value: rx_vga_gain
  states: {}
- name: gui_tx_bandwidth
  id: variable_qtgui_range
  parameters:
    gui_hint: 'tabs@1 : 1, 2, 1, 2'
    label: Bandwidth
    start: 1.5e6
    step: 0.5e6
    stop: 28e6
    value: tx_bandwidth
  states: {}
- name: gui_tx_frequency
  id: variable_qtgui_range
  parameters:
    gui_hint: 'tabs@1 : 0, 0, 1, 5'
    label: Frequency
    start: '0'
    step: 1e6
    stop: 3.8e9
    value: tx_frequency
  states: {}
- name: gui_tx_sample_rate
  id: variable_qtgui_range
  parameters:
    gui_hint: 'tabs@1 : 1, 0, 1, 2'
    label: Sample Rate
    start: 1.5e6
    step: 500e3
    stop: 40e6
    value: tx_sample_rate
  states: {}
- name: gui_tx_vga1
  id: variable_qtgui_range
  parameters:
    gui_hint: 'tabs@1 : 0, 5, 1, 2'
    label: VGA1 Gain
    start: '-35'
    step: '1'
    stop: '-4'
    value: tx_vga1
  states: {}
- name: gui_tx_vga2
  id: variable_qtgui_range
  parameters:
    gui_hint: 'tabs@1 : 0, 7, 1, 2'
    label: VGA2 Gain
    start: '0'
    step: '1'
    stop: '25'
    value: tx_vga2
  states: {}
- name: qpsk_constellation
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '4'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.3'
    type: complex
  states: {}
- name: digital_constellation_encoder_bc_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: qpsk_constellation
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk_constellation
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: '8'
  states: {state: disabled}
- name: digital_psk_mod_0
  id: digital_psk_mod
  parameters:
    constellation_points: '4'
    differential: 'True'
    excess_bw: '0.35'
    mod_code: '"none"'
    samples_per_symbol: '8'
  states: {state: disabled}
- name: instance
  id: parameter
  parameters:
    label: 0-indexed device instance describing device to use. Ignored if a serial-number is provided.
    type: intx
    value: '0'
  states: {}
- name: loopback
  id: parameter
  parameters:
    label: Loopback mode
    short_id: l
    value: '"none"'
  states: {}
- name: note_0
  id: note
  parameters:
    note: Command line params
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: GUI Controls
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: bladerf_tx_args
    bb_gain0: gui_tx_vga1
    bw0: gui_tx_bandwidth
    freq0: gui_tx_frequency
    gain0: gui_tx_vga2
    if_gain0: '0'
    sample_rate: gui_tx_sample_rate
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: bladerf_rx_args
    bb_gain0: gui_rx_vga_gain
    bw0: gui_rx_bandwidth
    dc_offset_mode0: '1'
    freq0: gui_rx_frequency
    gain0: gui_rx_lna_gain
    gain_mode0: 'False'
    if_gain0: '0'
    iq_balance_mode0: '1'
    sample_rate: gui_rx_sample_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: gui_rx_sample_rate
    fc: gui_rx_frequency
    fftsize: '8192'
    gui_hint: 'tabs@0 : 2, 0, 5, 5'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: gui_tx_sample_rate
    fc: gui_tx_frequency
    fftsize: '8192'
    gui_hint: 'tabs@1 : 2, 0, 5, 5'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 'tabs@0 : 7, 0, 3, 10'
    label1: ''
    label2: ''
    size: '8192'
    srate: rx_sample_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 'tabs@1 : 7, 0, 3, 10'
    label1: ''
    label2: ''
    size: '8192'
    srate: tx_sample_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: gui_rx_sample_rate
    fc: gui_rx_frequency
    fftsize: '8192'
    gui_hint: 'tabs@0 : 2, 5, 5, 5'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: gui_tx_sample_rate
    fc: gui_tx_frequency
    fftsize: '8192'
    gui_hint: 'tabs@1 : 2, 5, 5, 5'
    showports: 'True'
    type: complex
  states: {}
- name: rx_bandwidth
  id: parameter
  parameters:
    label: Bandwidth
    type: eng_float
    value: 1.5e6
  states: {}
- name: rx_buflen
  id: parameter
  parameters:
    label: Length of RX buffers, in samples. Should be a multiple of 1024.
    value: '4096'
  states: {}
- name: rx_frequency
  id: parameter
  parameters:
    label: Frequency
    type: eng_float
    value: 915e6
  states: {}
- name: rx_lna_gain
  id: parameter
  parameters:
    label: RX LNA Gain
    type: intx
    value: '6'
  states: {}
- name: rx_num_buffers
  id: parameter
  parameters:
    label: Number of RX buffers to use
    type: intx
    value: '16'
  states: {}
- name: rx_num_xfers
  id: parameter
  parameters:
    label: Number of maximum in-flight RX USB transfers. Should be <= (num-buffers / 2).
    type: intx
    value: '8'
  states: {}
- name: rx_sample_rate
  id: parameter
  parameters:
    label: Sample Rate
    type: eng_float
    value: 3e6
  states: {}
- name: rx_vga_gain
  id: parameter
  parameters:
    label: RX VGA1 + VGA2 Gain
    type: intx
    value: '20'
  states: {}
- name: serial
  id: parameter
  parameters:
    label: bladeRF serial number
    value: '""'
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    label0: RX
    label1: TX
    num_tabs: '2'
  states: {}
- name: tx_bandwidth
  id: parameter
  parameters:
    label: Bandwidth
    type: eng_float
    value: 1.5e6
  states: {}
- name: tx_buflen
  id: parameter
  parameters:
    label: Length of TX buffers, in samples. Should be a multiple of 1024.
    value: '4096'
  states: {}
- name: tx_frequency
  id: parameter
  parameters:
    label: Frequency
    type: eng_float
    value: 915e6
  states: {}
- name: tx_num_buffers
  id: parameter
  parameters:
    label: Number of TX buffers to use
    type: intx
    value: '16'
  states: {}
- name: tx_num_xfers
  id: parameter
  parameters:
    label: Number of maximum in-flight TX USB transfers. Should be <= (num-buffers / 2).
    type: intx
    value: '8'
  states: {}
- name: tx_sample_rate
  id: parameter
  parameters:
    label: Sample Rate
    type: eng_float
    value: 3e6
  states: {}
- name: tx_vga1
  id: parameter
  parameters:
    label: TX VGA1 Gain
    type: intx
    value: '-18'
  states: {}
- name: tx_vga2
  id: parameter
  parameters:
    label: TX VGA2 Gain
    type: intx
    value: '0'
  states: {}
- name: verbosity
  id: parameter
  parameters:
    label: 'libbladeRF log verbosity. Options are: verbose, debug, info, warning, error, critical, silent'
    value: '"info"'
  states: {}

connections:
- [analog_random_source_x_0, '0', digital_constellation_encoder_bc_0, '0']
- [analog_random_source_x_0, '0', digital_constellation_modulator_0, '0']
- [analog_random_source_x_0, '0', digital_psk_mod_0, '0']
- [blocks_multiply_const_vxx_0, '0', osmosdr_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [digital_constellation_encoder_bc_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_psk_mod_0, '0', blocks_multiply_const_vxx_0, '0']
- [osmosdr_source_0, '0', qtgui_const_sink_x_1, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_time_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
