options:
  parameters:
    author: Osaze Shears
    generate_options: qt_gui
    id: qpsk_txrx
    output_language: python
    title: QPSK TX RX
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: '70000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '544000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: variable_constellation_0
  id: variable_constellation
  parameters:
    const_points: '[-1-1j, 1+1j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1]'
    type: calcdist
  states: {}
- name: variable_qtgui_range_0
  id: variable_qtgui_range
  parameters:
    label: Phase Shift
    start: '0'
    step: '0.001'
    stop: 2*3.14
    value: '3.589'
  states: {}
- name: variable_qtgui_range_0_0
  id: variable_qtgui_range
  parameters:
    label: Amplitude Shift
    start: '0'
    step: '0.001'
    stop: '2'
    value: '1.603'
  states: {}
- name: variable_qtgui_range_delay
  id: variable_qtgui_range
  parameters:
    label: Time Delay
    min_len: '16'
    rangeType: int
    start: '0'
    step: '1'
    stop: '128'
    value: '45'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '16'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: variable_qtgui_range_delay
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/oshears/Documents/bladeRF/bladerf_dfr_accelerator/gnu_radio/qpsk/tx_data.bin
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/oshears/Documents/bladeRF/bladerf_dfr_accelerator/gnu_radio/qpsk/tx_data_complex.bin
    type: complex
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: /home/oshears/Documents/bladeRF/bladerf_dfr_accelerator/gnu_radio/qpsk/rx_data_complex.bin
    type: complex
  states: {}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: /home/oshears/Documents/bladeRF/bladerf_dfr_accelerator/gnu_radio/qpsk/rx_data.bin
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/oshears/Documents/bladeRF/bladerf_dfr_accelerator/gnu_radio/qpsk/tx_data.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: variable_qtgui_range_0_0
    type: complex
  states: {}
- name: blocks_phase_shift_0
  id: blocks_phase_shift
  parameters:
    is_radians: 'True'
    shift: variable_qtgui_range_0
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: variable_constellation_0
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: variable_constellation_0
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: sps
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: (2*3.14)/100
  states: {}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: soapy_bladerf_sink_0
  id: soapy_bladerf_sink
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_file_sink_0, '0']
- [analog_random_source_x_0, '0', digital_constellation_modulator_0, '0']
- [blocks_delay_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_file_source_0, '0', digital_constellation_modulator_0, '0']
- [blocks_multiply_const_vxx_0, '0', digital_symbol_sync_xx_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_file_sink_0_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', digital_constellation_decoder_cb_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_const_sink_x_0, '1']
- [blocks_multiply_const_vxx_1, '0', qtgui_time_sink_x_0, '1']
- [blocks_phase_shift_0, '0', blocks_delay_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_file_sink_0_1, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_multiply_const_vxx_1, '0']
- [digital_symbol_sync_xx_0_0, '0', blocks_file_sink_0_0, '0']
- [digital_symbol_sync_xx_0_0, '0', qtgui_const_sink_x_0, '0']
- [digital_symbol_sync_xx_0_0, '0', qtgui_time_sink_x_0, '0']
- [digital_symbol_sync_xx_0_0, '0', soapy_bladerf_sink_0, '0']
- [soapy_bladerf_source_0, '0', blocks_phase_shift_0, '0']
- [soapy_bladerf_source_0, '0', digital_costas_loop_cc_0, '0']

metadata:
  file_format: 1
